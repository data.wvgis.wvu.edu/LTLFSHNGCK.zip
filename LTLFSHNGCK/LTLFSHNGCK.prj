HEC-RAS study LTLFSHNGCK.prj: LTLFSHNGCK

--- LTLFSHNGCK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,72971   ,65.4,65.7,66.9
BEGIN DESCRIPTION:
Structure 17 XS 3
END DESCRIPTION:
XS GIS Cut Line= 5
1633056.25491502411818.0966548991633193.50266263412323.746251362
1633148.35537723412612.6888779121633117.65522316412661.447946142
1632909.97771033412917.884527205
#Sta/Elev= 30
       0  852.28    56.4  838.47   114.4  815.22   193.2  792.54   230.5  789.46
   296.8  788.25   325.8  786.34   400.4  785.46   450.2  782.84   686.9  777.47
   702.9  776.53   725.4  771.56   742.9   770.9   751.5  771.49   763.6  775.64
   771.7  780.77   775.8  781.73   812.2   780.9   825.7  786.67   876.5  789.96
   897.2  794.43     950   810.4   996.8  815.32    1017  819.74  1093.4  840.45
  1114.8  842.42  1150.8  848.07  1164.5  851.82  1187.9  854.58    1204  859.02
#Mann= 7 ,-1,0
       0      .1       0     210     .06       0     320     .05       0
  723.95     .06       0   725.4    .045       0   751.5     .06       0
  904.01      .1       0
Bank Sta=725.4,751.5
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72905   ,396.9,399.7,402.5
BEGIN DESCRIPTION:
Structure 17 XS 2
END DESCRIPTION:
XS GIS Cut Line= 4
 1633009.3017382411870.4675059611633137.52002873412312.910902866
1633079.73150342412610.8829864961632877.47166484412914.272744373
#Sta/Elev= 30
       0   846.4    39.6  836.03      73  820.86   143.8  795.06   185.4  789.07
   533.6   780.8   594.7  777.62   651.8   777.5   659.9  776.71  673.22 772.116
   680.3  771.27  702.13772.1662   712.9  780.83     717  782.15   745.5  782.29
   753.6  784.13   757.7  786.61   766.2  794.79   775.8  806.78   785.4  815.92
   814.2  827.85   834.3  832.55   864.4  837.21     951  839.48  1018.9  850.37
    1060  854.84  1097.9  861.49  1102.7  863.57  1117.6  874.64  1128.8  879.32
#Mann= 6 ,-1,0
       0      .1       0     260     .05       0  670.65     .06       0
  673.22    .045       0  702.13     .06       0  764.17      .1       0
Bank Sta=673.22,702.13
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72506   ,496,499.4,501
BEGIN DESCRIPTION:
Structure 17 XS 1
END DESCRIPTION:
XS GIS Cut Line= 6
1632952.04958068411785.2321737561632872.82204884411970.019533843
1632836.77979809412061.8037990931632722.67011817412395.983905002
1632679.52052984412517.7072575761632068.37030383412872.208773957
#Sta/Elev= 30
       0  869.78    29.7  860.03   129.8  839.48   195.1  819.88   246.7  807.88
   408.2  782.17   538.7  776.44   611.2  775.34   666.1   776.8680.3981771.6039
     717  770.31722.5953 771.645     743  780.65   752.4  787.42   763.7  790.05
   787.6   791.1   832.1  785.88   901.5  789.86   952.3  817.55   989.3  834.27
  1034.7  844.71  1049.9  845.86  1096.7  854.77  1109.6  854.66  1178.9  876.78
  1363.9  920.77  1409.9  933.97  1433.3   945.2  1451.8   949.4  1488.5  961.85
#Mann= 6 ,-1,0
       0      .1       0  261.06     .05       0  672.79     .06       0
680.3981    .045       0722.5953     .06       0  781.93      .1       0
Bank Sta=680.3981,722.5953
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72006   ,266.4,269.1,272.4
BEGIN DESCRIPTION:
Structure 16 XS 4
END DESCRIPTION:
XS GIS Cut Line= 6
  1632569.894177411606.1364033371632480.97571968411783.973974168
1632436.95284183411872.0187455861632312.57152893 412120.78137143
1631987.99376601412769.940506175 1631943.4469391412859.033831924
#Sta/Elev= 30
       0   864.7    29.5     855    92.1  844.89   132.4  828.76   172.6  817.32
   226.7  807.71   414.1  779.51   512.9  774.65     671  775.01   683.7  769.34
   691.4  768.14   722.7  769.43   749.5   788.9   767.4  791.37   799.2  791.89
   803.2  794.74     823  815.72     839  829.08   950.8  852.14  1007.9  866.17
  1102.8  899.19  1120.7  902.51  1183.8  919.64  1201.6  927.08  1228.5  935.24
  1259.4  948.89  1304.1  962.37  1339.9  976.72  1384.6  985.63  1400.8  991.48
#Mann= 6 ,-1,0
       0      .1       0  357.27     .05       0  575.39      .1       0
   683.7    .045       0   722.7     .06       0  800.39      .1       0
Bank Sta=683.7,722.7
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71737   ,103,103.4,103.9
BEGIN DESCRIPTION:
Structure 16 XS 3
END DESCRIPTION:
XS GIS Cut Line= 4
1632521.29324724411620.0751754751632163.72674688411904.503073485
1631958.93866032412187.3056692211631768.77829422412218.186412434
#Sta/Elev= 30
       0  856.07    18.2  848.35    98.6  825.04   132.1  817.98   161.4  813.58
   267.3  801.06   342.8  793.74   416.8  784.13     491  776.13   521.1  774.86
   600.2  774.84   639.7  772.35   654.5  772.83     660  772.32  671.12  768.33
   679.2  767.29     703  768.33   708.8  772.82   713.7  774.38     723  775.05
   742.7  780.09   783.2  784.23   797.7  785.22   829.2  784.04   873.8  785.31
   910.2  804.15   934.5  821.15     949  829.37     967  837.28   998.7  844.11
#Mann= 8 ,-1,0
       0      .1       0     390     .05       0  671.12    .045       0
     703     .05       0  706.89      .1       0  726.89     .07       0
  846.06     .06       0  946.06      .1       0
Bank Sta=671.12,703
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71634   ,129.9,127.5,125.1
BEGIN DESCRIPTION:
Structure 16 XS 2
END DESCRIPTION:
XS GIS Cut Line= 4
1632490.48508649411583.6962484521632063.03058834411873.000053285
1631880.99673362412116.7953944371631741.22073802412162.303858119
#Sta/Elev= 30
       0   852.9    28.2  842.34    75.3  830.26   120.4  821.22   189.5  811.29
   292.7  800.43   415.4   785.2   509.3  775.25   534.4  774.19   650.4  774.15
   672.2  772.21   680.8  768.43  687.91767.1188   690.3  767.06   715.1  767.16
   720.2  767.88   730.2   771.6   770.2  778.27   795.1  779.72   820.4  782.86
   843.1  783.25   849.5  786.87   863.4  799.03   871.8  810.63     876  815.01
   893.9   826.1   912.9   835.3   925.6  840.15   943.3   842.7   967.4  849.11
#Mann= 7 ,-1,0
       0      .1       0     430     .05       0  596.15      .1       0
  687.91    .045       0   715.1      .1       0  756.15     .06       0
  890.41      .1       0
Bank Sta=687.91,715.1
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71506   ,475.1,500,523
BEGIN DESCRIPTION:
Structure 16 XS 1
END DESCRIPTION:
XS GIS Cut Line= 6
1632485.10235184411551.5423524231632172.85658526411684.005670175
1631993.48391251411792.4916736781631868.63015959411908.853317589
1631786.44692501412063.355305165 1631683.5946415 412135.73121235
#Sta/Elev= 30
       0  852.06    31.5  840.27    48.9  839.72    70.6  836.52   170.1  814.79
   335.7  791.94   382.4  788.69   507.4  777.23   564.4  774.09   646.8  772.25
   738.1  773.57   742.5  772.38   751.6  767.08   772.4  766.12   788.4  766.98
   792.4  767.96   801.4  774.62   806.2  776.64   832.8  777.13   860.3   780.5
   878.5  780.49     883  781.67   891.9  788.08     903  799.79   907.9  806.11
     915  818.28   918.1  821.91   940.8  836.11   971.5  847.68    1021   859.1
#Mann= 7 ,-1,0
       0      .1       0  429.32     .05       0  740.23      .1       0
   751.6    .045       0   788.4      .1       0  850.23     .06       0
  975.23      .1       0
Bank Sta=751.6,788.4
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71006   ,530.7,499.6,462.2
XS GIS Cut Line= 6
1632485.76803292411536.0705985871632275.53682609411575.468485668
1631483.03972343411418.8500325081631383.50809833 411424.69024393
1631170.28608385411574.8795760871631072.06744826411721.134532928
#Sta/Elev= 30
       0  852.12    19.1  845.99    51.6  845.37   110.8  835.43     162   830.6
   190.9  820.97   230.4  814.02     352  797.53   409.3  792.45   470.9  782.01
   548.1  774.44   682.8  771.05   697.4 766.395   707.3  765.77   736.6  766.39
   760.4  770.05   776.7  777.51   833.9  775.28   854.3  781.57   936.4  787.02
  1037.7   808.2  1085.8  813.03  1199.6  839.58  1261.3  849.91  1298.1  852.17
  1330.4   859.3  1366.3  861.07  1511.8  897.75  1535.8  907.71  1560.7  913.07
#Mann= 7 ,-1,0
       0      .1       0   697.4    .045       0   736.6      .1       0
  776.47     .06       0  881.47      .1       0  968.97     .06       0
  978.97      .1       0
Bank Sta=697.4,736.6
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,70507   ,508.8,500.4,490
XS GIS Cut Line= 6
1631971.93671151410368.6365817491631706.98776634411070.507553339
1631652.88879317411132.1527712491631277.42104018411445.928062335
1631170.40845892411555.8372913451631072.12879984411711.613554582
#Sta/Elev= 30
       0 1070.93    29.8 1053.08    89.6 1029.18   115.3 1012.81   249.3  965.91
   281.1  945.34   335.1  920.64   381.7  907.76   440.1  882.88     517  857.41
   555.5  851.83   598.2  829.49   645.3   797.4  675.88766.2574   707.6  764.74
   726.7  766.25   748.1  770.19     968  771.29   993.6  778.39  1025.7  775.29
  1040.9  780.75    1110  786.58  1158.5  795.89  1182.6  806.01  1236.7  807.22
  1296.4  826.14  1420.3  855.13  1461.2  856.93  1584.4  886.36  1659.3   910.8
#Mann= 7 ,-1,0
       0      .1       0  675.88    .045       0   726.7      .1       0
  993.74     .06       0 1158.03      .1       0 1257.38     .05       0
 1307.38      .1       0
Bank Sta=675.88,726.7
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,70006   ,506.6,500,490.3
XS GIS Cut Line= 6
1631195.08524685410232.7461055071631256.62941509411143.559900671
1631266.99487992411333.9191000011631218.91984484411438.626895845
1631141.15786126411552.1867080931631057.50350101411709.788098916
#Sta/Elev= 30
       0 1103.61    19.8 1089.41    55.9 1076.74   204.3  999.04   224.3  993.72
   240.3  981.38   272.4  970.32   296.5  950.85   324.5  942.26   356.6  921.97
   432.6  884.37   475.9  868.37   544.7  852.09   601.6  812.31   625.2  801.91
   681.3  764.08   691.8  762.61  719.08763.9776   741.5  768.28   889.8  770.37
   925.9   777.1     962  773.27    1014  779.78  1103.5  799.33  1172.4  808.71
    1255  840.47  1424.7  872.92  1469.8  889.58  1510.8  898.63  1534.8  909.55
#Mann= 7 ,-1,0
       0      .1       0   681.3    .045       0  719.08      .1       0
  905.39     .07       0 1002.89      .1       0 1103.53     .05       0
 1193.53      .1       0
Bank Sta=681.3,719.08
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,69506   ,509.3,500.7,490.1
XS GIS Cut Line= 6
1630460.80948442410401.5712271781630735.40736042410991.150756672
1630809.29271135 411149.788562761630968.27959809411491.142538846
1631010.16993426411581.084616169 1630992.0095375411724.236888915
#Sta/Elev= 30
       0 1057.61   184.2  976.66   206.3  971.92   263.6  947.62   276.9  946.49
   302.8  937.05     369  909.87   393.1   897.1   415.2  890.85   435.7     879
   515.1  858.22   540.6  854.45   557.3  848.02   585.7  827.59   636.9  800.09
     658   778.4  683.32  763.05   722.5  761.67   731.3     763   742.3  766.99
   982.9  771.68  1009.3  775.99  1066.7  778.23  1137.3  804.66  1163.7  822.52
  1234.4  853.26  1304.7  869.16  1377.2  891.64  1401.4  896.36  1445.5  911.49
#Mann= 6 ,-1,0
       0      .1       0  683.32    .045       0   731.3      .1       0
  810.39     .05       0  922.89     .06       0 1026.64      .1       0
Bank Sta=683.32,731.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,69005   ,398.3,409.2,416.1
XS GIS Cut Line= 6
1629883.25880225410818.2820079181629994.78843483410987.308900833
1630056.77715601411065.1601230951630127.30194934411131.656709254
1630393.70036668411368.1897007531630842.77131893411842.081141427
#Sta/Elev= 30
       0  973.81    45.3  969.84   101.6  955.47   143.9  949.43   382.8  898.73
     464  863.98     512  855.17   533.4  842.69   567.4  814.93     600  802.16
   624.2  778.36   636.3  769.44   648.4   765.2   677.9  761.56   692.1  760.97
  725.59761.5838   737.9  765.78   922.7  768.98   966.3  772.34   983.5  776.88
  1016.3     776  1032.8  783.27  1059.6     803  1093.1  816.33  1158.8  853.11
  1273.7  877.02    1301  889.49  1340.6  900.44  1362.7  910.58  1408.1  921.08
#Mann= 5 ,-1,0
       0      .1       0   677.9    .045       0  725.59      .1       0
  850.44     .06       0  978.26      .1       0
Bank Sta=677.9,725.59
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,68596   ,577.1,583.3,590.9
XS GIS Cut Line= 4
1629843.23122782410851.2648563151629973.14529319411451.027810098
1630147.56922669411808.8333437571630410.53949255412156.663726633
#Sta/Elev= 30
       0  950.69    66.8  940.55   132.3  926.62   357.4  864.49   455.6  849.42
   496.3  837.21   549.7  816.78   582.5  800.45   602.9  785.79   642.1  769.91
   682.1  764.19   691.8  759.89   713.3   759.5   727.7  759.88   748.7  765.34
   847.4  765.79   891.2  771.95  1006.9  778.11  1011.4  779.85  1021.4  792.29
  1031.4  798.39  1136.7  846.56  1171.8  855.09    1189  862.82  1257.5  875.88
  1314.6  898.04  1337.4  909.93  1411.7  938.62  1434.5  945.05  1447.8  953.03
#Mann= 6 ,-1,0
       0      .1       0   691.8    .045       0   727.7      .1       0
  813.67     .05       0  923.67     .06       0 1031.73      .1       0
Bank Sta=691.8,727.7
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,68013   ,391,406.5,399.9
XS GIS Cut Line= 6
  1629747.317145410873.9882613421629683.20014726411214.906214669
1629477.64708067411588.4865042571629482.06144193411689.521079093
1629562.83588667412133.8003742551629579.45232326412332.667430595
#Sta/Elev= 30
       0  921.97   161.8  869.46   237.2  857.68   284.4  860.91   324.4  856.75
   423.9  819.11   489.9  801.55   512.9  798.73   569.2   781.8   619.5  775.11
   651.9     767   719.1  762.34   782.1  762.72   810.1  758.78     826  757.22
  841.46  758.79   850.2  763.61   947.4  762.13  1000.2  770.25  1028.7  768.99
  1126.3  829.91    1171  850.45    1264  874.43  1292.9  887.31  1317.3  892.75
  1349.6  912.05  1454.5  942.54  1474.2   950.6  1494.3  967.11  1526.4  980.95
#Mann= 5 ,-1,0
       0      .1       0   810.1    .045       0  841.46      .1       0
  915.19     .06       0 1020.19      .1       0
Bank Sta=810.1,841.46
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,67607   ,597.5,600.4,604.7
XS GIS Cut Line= 5
1629427.01845621410821.8607247911629282.92494133  411418.6344904
1629282.92494133411483.1984531031629147.00080933411598.733965309
 1629011.8436135411990.913279126
#Sta/Elev= 30
       0  938.31    23.3  929.28    52.1  921.74   126.2  889.02   241.4  861.83
   315.5  826.48   418.4  791.14   481.9  779.22   541.6  775.05   615.8  765.34
   629.9757.1285   635.8  756.44   651.8   757.1   675.8  761.42   705.3  762.34
   834.4  758.42     863  772.63   926.5  772.51   930.7   774.9   943.4  796.16
   960.3  812.99  1019.6  854.83  1032.3  860.35  1065.1  865.73  1080.8  871.72
  1133.8  883.81  1146.5  889.91  1184.9  922.89  1222.6  936.68  1271.7  946.33
#Mann= 9 ,-1,0
       0      .1       0     430     .05       0     530      .1       0
   629.9    .045       0   651.8      .1       0  748.49     .06       0
  838.49      .1       0  886.88     .06       0  996.88      .1       0
Bank Sta=629.9,651.8
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,67006   ,523.2,503.2,479.1
XS GIS Cut Line= 6
1628946.05201526410664.2458986791628714.32970968411377.961990923
1628690.40554492411449.0484629271628690.53054467411546.394396842
1628702.18701743411662.1421968341628761.77810559412121.018575668
#Sta/Elev= 30
       0  862.19    87.5  867.01   155.9   860.5   181.1  850.67   239.4  818.42
   252.6  807.53   265.3  804.69   303.1  783.69   433.5  771.82   488.1  762.37
   673.2  761.52  685.24756.6072   706.8  754.74   719.5  756.58     770  763.27
   812.2  792.51   868.9  791.66   872.9  794.62   880.9  811.12   888.9  819.94
   908.9   822.6   980.9   852.7  1097.9  856.23  1150.3  864.01  1186.6  858.66
    1231  877.24  1287.5  887.04  1315.8     884  1360.3  901.82  1501.8  928.93
#Mann= 6 ,-1,0
       0      .1       0  394.14     .05       0  685.24    .045       0
   719.5      .1       0  810.39     .06       0  905.39      .1       0
Bank Sta=685.24,719.5
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,66503   ,489.2,496.2,497.5
XS GIS Cut Line= 6
 1627783.2954825411041.5735560951628121.01757608411311.159959167
1628604.82402317411614.8913070861628659.33375667411696.390487924
1628695.52069217  411796.74297751628759.09996134412123.159319416
#Sta/Elev= 30
       0  958.15    84.8  921.83   138.7  888.72   213.6  868.26   244.5  851.63
   264.7  833.97   301.1  822.44   352.7  786.91     402  766.69   513.6  759.59
   746.4  761.08   770.2  755.22   785.2     754   803.3  755.17   851.2  783.44
   892.4  781.89   905.6  789.03   942.9  796.97   965.8  810.81  1005.2     825
  1098.1  845.23  1124.6   842.9  1142.1  848.92  1167.2  846.35  1188.4  849.25
  1238.5  869.22  1316.7  884.34  1349.4  881.73  1390.1  899.11  1542.7  928.77
#Mann= 9 ,-1,0
       0      .1       0   472.6     .05       0   512.6      .1       0
  623.89     .05       0  732.21      .1       0   770.2    .045       0
   803.3      .1       0  862.68     .07       0  977.68      .1       0
Bank Sta=770.2,803.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,66007   ,491,500.6,504.4
XS GIS Cut Line= 6
1627571.84971118411174.2225690041627674.43251126411347.825896338
1627730.82413076411429.608869255  1628091.470063411816.793134257
1628150.00603518411886.3595961781628448.15931025412288.254789755
#Sta/Elev= 30
       0 1005.04    63.5  989.29    76.4  988.33   110.3  972.42   188.9   951.4
   231.7  935.95     268   918.8   309.7  906.35   342.3  890.63   425.8  872.42
     482   836.3   511.5  821.34   535.1  800.38   564.5  785.68   601.3  761.36
   617.6  757.84   673.6  759.34   682.1  754.51   693.8   753.8   717.1  754.45
   750.6  759.15   840.3  759.42   876.9  765.36   949.3  769.39   975.5  775.45
  1030.4  776.37  1140.4  786.49  1170.2  783.33  1224.7  782.97  1421.6  791.31
#Mann= 10 ,-1,0
       0      .1       0   682.1    .045       0   717.1      .1       0
  824.16     .05       0  840.22     .06       0  971.14     .07       0
 1098.62      .1       0 1138.61     .06       0 1218.61      .1       0
 1309.52     .06       0
Bank Sta=682.1,717.1
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65506   ,495.4,500,504.1
XS GIS Cut Line= 6
1627429.65970685411229.6912900951627396.34842175411351.364931256
1627381.79989442411465.4710022511627416.53342076 411557.59384951
1627611.76268908412048.3094035091627831.05358909412580.322447091
#Sta/Elev= 30
       0  972.69    69.3  952.88    81.7  946.74    94.2  946.77   171.7  918.51
   220.4  905.43   334.2  879.35     371  873.51   407.4  872.86   467.9  860.43
     515   841.1   560.3  826.69   605.4  804.21   714.3  762.61   726.6  754.08
   734.5  752.53   763.5  753.93   769.7  757.61   777.6  758.86   908.1  758.27
   953.4  761.37  1196.7   759.9    1227  773.39  1260.5  774.73  1313.6  783.04
  1335.2  793.57  1361.5  801.25  1370.7  807.12  1395.8  829.18  1443.2  862.23
#Mann= 7 ,-1,0
       0      .1       0   726.6    .045       0   763.5      .1       0
  812.76     .05       0  947.76     .03       0  1165.9     .07       0
 1264.35      .1       0
Bank Sta=726.6,763.5
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65006   ,484.5,500,517.1
XS GIS Cut Line= 6
1627401.84677035411242.4740729181627340.72222067411376.931153089
1627123.89391418411804.9325936731627083.00849725411939.154766172
1627112.75843775412104.6816660911627223.30053951412846.885234177
#Sta/Elev= 30
       0  963.32    52.5  940.19   100.8  926.39   135.8  924.63   156.2  921.05
   228.3  900.45   349.3  877.41   399.2  863.16   507.3  819.26   520.5  816.78
   552.2  802.21   587.1   792.7   723.3  775.68   773.3  758.47   838.1  756.75
   952.1  758.58   968.3  752.48   984.7   751.9  1005.8  752.53    1033  758.26
  1049.2  755.18  1069.4  758.19  1239.3  759.83  1271.6  765.23  1360.6  765.55
  1376.8  777.81  1421.2  795.69  1522.3  821.71  1606.7  830.77  1686.5  831.94
#Mann= 6 ,-1,0
       0      .1       0   968.3    .045       0  1005.8      .1       0
 1056.09     .07       0 1352.34     .06       0 1507.66      .1       0
Bank Sta=968.3,1005.8
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,64506   ,673.4,666.8,672.7
XS GIS Cut Line= 6
1627396.71849975411238.3169290131627250.03440993411499.974214092
1627041.84125675411738.4173067511626918.90318242411806.123864248
 1626753.0180155411864.9036023321626230.45442809412404.178770512
#Sta/Elev= 30
       0  966.43    38.4   951.1    65.3  936.79   133.7  929.04   239.9  900.09
   326.1  881.17   418.9  852.37   552.2  802.09   628.5  783.21   799.6  756.48
   850.3  754.38   923.4  756.49   967.5   754.1   973.4  751.13   973.4   751.1
  1001.8  750.66  1009.4  751.24  1024.4  756.19  1115.1   759.6  1134.6  779.73
    1149  788.51  1168.8  805.42  1194.3  818.25  1233.6  844.13  1262.5  857.28
  1296.1  880.76  1335.7  894.97  1383.8  904.35  1423.1  908.26  1687.5  921.04
#Mann= 7 ,-1,0
       0      .1       0   973.4    .045       0  1009.4      .1       0
 1016.23     .06       0 1161.23      .1       0 1568.03     .08       0
 1578.03      .1       0
Bank Sta=973.4,1009.4
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,63839   ,330.5,333.2,332.1
XS GIS Cut Line= 2
1626993.62335653411107.2074476711626183.02280479411948.085099816
#Sta/Elev= 30
       0  946.12      31  926.04    74.1  912.04     101   900.1   157.6  890.59
   209.7   876.4   257.4  842.77   290.3  824.35     316  800.66   327.3  796.98
     350  784.55   372.6  767.32   389.6  761.72   403.7  749.95   424.1   749.1
   440.8  749.99   451.9  753.98     469  755.51     590  754.84   693.8  754.71
   718.6  761.59   757.2  759.31   782.8  778.87   809.1  784.19   846.4  804.05
   901.9  825.19   957.5  840.66  1039.6  847.13    1159  840.31    1168  842.59
#Mann= 6 ,-1,0
       0      .1       0   403.7    .045       0   440.8      .1       0
     590     .05       0     700     .06       0     730      .1       0
Bank Sta=403.7,440.8
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,63506   ,530,500,482.7
XS GIS Cut Line= 6
1626783.60784934410681.0152220881626593.43500134411032.089651167
1626145.63766859 411582.287041591626078.91962618411677.155290172
1626010.54115401411813.312170088 1625951.5435686411961.427359417
#Sta/Elev= 30
       0 1042.28    39.7 1054.47    58.9 1053.61   100.6 1028.19   123.3 1023.13
   149.3 1005.48   174.8  999.82   204.4  976.99   233.9  966.12   283.7   937.4
   326.5  905.26     392  882.08   429.8  860.97   489.3   820.9   514.7  811.58
   603.4  765.11   668.4  748.63   676.1  747.68   719.6  748.65   736.6  753.52
     879  754.92     951  766.42   983.8   763.1    1069  776.55  1111.6   779.5
    1126  790.16  1150.8  798.44  1322.7  845.19  1443.2   861.6  1536.7  864.39
#Mann= 6 ,-1,0
       0      .1       0   668.4    .045       0   719.6      .1       0
  785.83     .05       0  918.33     .06       0 1168.96      .1       0
Bank Sta=668.4,719.6
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,63006   ,513.4,500,489.4
XS GIS Cut Line= 6
1625806.47561726410460.0327244251625960.91822176411270.845407262
1626018.54901201411543.0476187621626015.37513384411657.535578758
1625978.76923592411803.5024784211625935.65744551411956.522185504
#Sta/Elev= 30
       0  862.96    57.5  900.57   118.6  914.28   212.3  953.09   261.1  961.85
   326.8  963.11   342.6  958.63   432.1  909.11   493.2  894.69   517.6   882.8
   549.1   858.6   599.1  827.83   631.2  793.41   647.9  780.31   668.3  748.51
   706.4  746.34   725.3  748.37   745.7  752.92   975.1  755.53   998.7  762.09
  1047.8  762.61    1097  779.57  1117.1  781.85  1141.1   793.3  1169.2  795.72
  1201.4  812.89  1295.5  842.88  1415.4  872.75  1466.9  878.55  1527.6  875.06
#Mann= 8 ,-1,0
       0      .1       0   668.3    .045       0   725.3      .1       0
  895.39     .05       0  992.89     .06       0 1193.64      .1       0
 1213.64     .06       0 1288.17      .1       0
Bank Sta=668.3,725.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,62506   ,489.5,500,511.8
XS GIS Cut Line= 6
1625424.25230034 410612.517983751625343.62155609410775.183340833
1625278.12759259410941.7272990941625274.16467401411071.225071594
1625865.44892451411882.5269266671625878.99745384411996.034573674
#Sta/Elev= 30
       0  898.19   238.9  880.92     382  861.99   468.7  846.59   546.1  814.54
   589.7  828.02   642.8  837.12   721.4   836.9   778.8  818.73   807.3  798.16
   826.2  787.94   860.1   746.1   892.6  745.19   907.5  746.08   907.5  746.11
   917.4  751.31  1087.9  755.59  1110.4  760.46  1140.1  758.07  1150.9  761.08
  1209.4  763.53  1214.3  765.32  1239.1  788.16  1265.4  798.17  1318.3  831.52
    1337  833.63  1359.9  850.58    1442  881.46    1500  891.34  1608.3  888.63
#Mann= 9 ,-1,0
       0      .1       0   860.1    .045       0   907.5      .1       0
  1058.2     .08       0  1088.2     .06       0  1185.7      .1       0
 1249.45     .06       0 1424.76      .1       0 1533.98     .07       0
Bank Sta=860.1,907.5
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,62006   ,465.7,497.9,536.8
XS GIS Cut Line= 6
1625413.25133809410620.3627843411625234.12275934410973.106173337
1625186.15533559411133.9831481731625088.85008401411541.459039256
 1625090.8622191411619.0838840011625192.90138508 412362.50464125
#Sta/Elev= 30
       0  897.36   284.2  875.17   445.1  850.84   519.1  835.18   578.5  826.18
   697.1  799.05   965.2  752.38  1066.2   750.9    1090   746.2  1102.1  744.87
 1134.91 746.104  1142.5  750.44    1195  750.31  1231.3  756.86  1251.5  754.97
  1275.7  765.32  1320.1  778.99  1392.8   817.1    1417  825.69  1429.1  838.86
  1442.5  849.07  1481.7  868.97  1520.6  897.44  1546.2  908.85  1582.6  913.85
  1611.8  924.34  1663.3  964.39  1687.5  977.25  1752.1  996.96  1810.7 1011.33
#Mann= 5 ,-1,0
       0      .1       0    1090    .045       0 1134.91      .1       0
 1170.27     .07       0 1275.27      .1       0
Bank Sta=1090,1134.91
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,61508   ,487.1,502.1,495.8
XS GIS Cut Line= 6
1625411.51938617410617.0701400041625227.19560784410959.935596004
1625128.18596335411221.8438648431625062.96398093411309.749200836
1624807.93397917411372.1312939231624173.54449992411669.545725346
#Sta/Elev= 30
       0  897.11   239.4  880.72     381  861.03   590.1     826   667.9   805.3
   708.5  799.08     750   788.3   839.4  771.42   884.6  766.19   905.1  761.39
   921.5  746.74  970.34745.6215   995.7  742.72    1062  745.55  1085.5  750.97
  1295.2  752.68  1336.3  757.16  1374.2  765.47  1404.8  767.09  1487.7  799.58
  1505.2  804.03    1527  825.64  1553.9     843  1574.8  863.26  1613.9  877.99
  1630.2  889.37  1648.7   908.9  1687.8   917.7  1718.7  928.27  1742.7  943.53
#Mann= 7 ,-1,0
       0      .1       0  916.28     .07       0  970.34    .045       0
    1062     .07       0 1130.53     .05       0 1236.81     .07       0
 1350.95      .1       0
Bank Sta=970.34,1062
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,61006   ,469.4,467.8,464.6
BEGIN DESCRIPTION:
Structure 15 XS 3
END DESCRIPTION:
XS GIS Cut Line= 6
1625394.53123118410597.7949160931625159.24364401410882.833716094
1625036.39677684410953.438561752  1624926.027575410981.195067927
1624657.53631409410993.4978648421624224.64774418410858.404631093
#Sta/Elev= 30
       0  893.96    93.2  889.14   238.1  875.08   303.4  866.54   333.1  859.46
   382.9     855   536.8   821.8   573.9   809.5   586.3  808.33   639.7  791.14
   692.4  776.52   748.9  756.88     805  751.67   904.9  748.57  925.18742.9409
   939.4  741.64   971.2  742.96     985  752.29  1038.9  753.02  1041.7  754.14
    1043  754.92  1047.2  763.33  1059.6  795.91  1064.5  804.16    1071  807.78
  1113.9  823.13  1181.2  839.46  1252.9  854.64  1329.5  866.76  1350.1  868.51
#Mann= 8 ,-1,0
       0      .1       0  521.74     .12       0  621.74      .1       0
  925.18    .045       0   971.2      .1       0 1026.44     .06       0
 1111.44     .05       0 1332.95      .1       0
Bank Sta=925.18,971.2
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,60538   ,76.4,76.8,76.6
BEGIN DESCRIPTION:
Structure 15 XS 3
END DESCRIPTION:
XS GIS Cut Line= 6
1625390.99031217410599.2941605421624914.34870264410492.073623162
1624809.00387958410526.8327831171624598.20209461410519.204802495
1624310.34120613 410544.885467291624193.86305514410677.291394866
#Sta/Elev= 30
       0  893.68    84.9  884.04   302.2  845.89   413.1  815.86   445.7  801.42
     470  787.01   486.7  774.82     512  762.31   524.6  754.16     533  751.38
   668.6  746.44   672.6  745.87   680.6  740.81   691.6  740.28   708.7  739.78
  715.58740.2606   724.7  742.83   736.8  742.95   760.9  746.91   776.9  746.63
     833  752.03   865.1  749.21   881.1  755.03   949.3  759.48   989.4  764.73
  1061.9  770.63  1103.4  778.18  1157.9  792.99  1211.4  814.15  1276.3  835.39
#Mann= 11 ,-1,0
       0      .1       0     270     .06       0     470     .07       0
  578.55     .06       0  676.25     .07       0   691.6    .045       0
  715.58     .07       0  775.27     .06       0   968.6     .05       0
 1072.35     .06       0 1092.35     .05       0
Bank Sta=691.6,715.58
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.8,0.6

Type RM Length L Ch R = 1 ,60462   ,467.7,455.4,422.7
BEGIN DESCRIPTION:
Structure 15 XS 2
END DESCRIPTION:
XS GIS Cut Line= 6
1625360.33242312410520.5278622231624890.28252638410426.490750433
 1624721.7167281 410451.962950581624573.94237049410426.575813487
1624279.68331708 410466.119168971624163.20516609410598.525096547
#Sta/Elev= 30
       0  868.38   110.4  855.82   183.7  838.86   249.1  826.71   343.5  795.84
   360.5  788.15   377.6  775.97   391.1  768.93   435.3  762.01   465.3  746.82
   627.7  744.81   635.7  743.96   646.6740.2056   651.7  739.91   683.9  740.23
   699.9  744.47   810.9  748.11   835.1  752.18   871.4  749.24   895.5  753.94
   971.6  760.32  1024.6  767.31    1037  767.05  1053.1  763.96  1093.4  763.56
  1110.6  768.61  1127.5  770.93  1194.1  789.87  1218.3   795.1  1274.2  802.27
#Mann= 12 ,-1,0
       0      .1       0     240     .06       0     390      .1       0
  589.36     .06       0  643.36     .07       0   646.6    .045       0
   683.9     .07       0  740.12     .06       0  840.96     .07       0
  935.76     .05       0 1040.24     .06       0 1157.88     .05       0
Bank Sta=646.6,683.9
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,60006   ,506.5,500,487.6
BEGIN DESCRIPTION:
Structure 15 XS 1
END DESCRIPTION:
XS GIS Cut Line= 6
1624998.34337525409427.0666145091624618.85496101410074.426212177
1624559.41446309410135.2646731731624386.40726317  410295.7932235
1624198.79018433410475.5116960851623962.66139151410656.044143423
#Sta/Elev= 30
       0 1011.04    15.6  1005.1    43.4 1000.33    80.5  998.05   177.9  984.44
     219  970.48   297.9  926.75   363.4  910.61     392  900.11   432.9  868.34
   463.2  838.34   496.7  818.09   542.3  828.92   573.9  829.51   593.2  824.73
   631.2  798.92     674  753.83   689.6  739.99   711.1  738.55  729.61739.9943
   758.9  743.95  1030.6  745.58  1049.2  752.12  1108.1  750.33  1222.1  762.16
  1274.5  763.38  1326.9     773  1446.5  772.67  1559.3  795.07  1628.5  815.78
#Mann= 9 ,-1,0
       0      .1       0   689.6    .045       0  729.61      .1       0
  865.45     .05       0 1007.01     .07       0 1141.46     .08       0
 1269.64     .06       0 1289.64     .05       0 1401.28      .1       0
Bank Sta=689.6,729.61
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,59506   ,501.3,500,499.9
XS GIS Cut Line= 6
1624231.93775584409271.8756519261624188.89683142409566.422963083
1624178.07795542409662.7187022571624106.65782267410467.394914418
1624038.76917893410560.8241894991623939.62830108 410654.01494801
#Sta/Elev= 30
       0  996.27    89.7  972.72   146.3  942.58   166.5  927.82   190.8  923.61
   231.2   909.7   274.2   911.3   299.8  907.42   344.1  898.05   388.4  882.38
   444.6  853.76   476.7  841.01   512.9  831.55   577.1  802.34   605.2  782.48
   633.3  752.82   653.4  737.91   685.5  737.04   709.6  737.87   818.6  745.35
   890.3   744.1   906.4  750.16   934.5  748.51   978.7  758.19    1059  760.43
  1123.2  774.13  1202.4  776.23  1262.3  790.96  1384.7     810    1454  828.79
#Mann= 6 ,-1,0
       0      .1       0   653.4    .045       0   709.6      .1       0
  790.83     .06       0  983.33     .05       0 1087.08      .1       0
Bank Sta=653.4,709.6
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,59006   ,491.6,500,499.5
XS GIS Cut Line= 6
1623802.21650243409243.1050401781623735.38494317409440.087913916
1623705.88893917409538.2084525821623685.43327142409634.551107675
1623662.53797601409814.7397236681623602.30417259 410637.93000643
#Sta/Elev= 30
       0  978.98    31.1  967.79    86.1  952.67   153.6  926.33   193.2  918.76
   237.7  906.12   391.5  851.79   455.4  837.11   491.7  819.91   519.9  809.48
   576.4  782.22   592.4   771.3   608.5  754.13   624.4  743.95   660.6  742.22
   672.6  737.84   692.7  736.62   708.7   735.5  733.78736.7032   744.8  740.25
     821  742.51   849.1  750.66   909.3  750.88   925.3  765.23   953.4  781.66
   997.5     806  1077.7  843.92  1171.9     857  1338.4  870.62    1416  874.26
#Mann= 6 ,-1,0
       0      .1       0   692.7    .045       0  733.78      .1       0
  735.61     .05       0  835.61     .06       0  928.11      .1       0
Bank Sta=692.7,733.78
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,58506   ,527.1,516.9,502.1
XS GIS Cut Line= 6
1623437.54498768409065.8104472611623123.31792584 410022.15039809
1623093.07914117410114.1853190061623054.72357485410205.453837261
1623008.91625176410295.4805600941622960.07120509410385.076181427
#Sta/Elev= 30
       0  927.74      66  918.77   145.5  913.75   293.4  889.48   339.7  885.25
     365  879.45   453.5  850.16   491.3  840.37     525  820.78   554.4  812.02
   630.8  783.02   642.8  775.56   659.7  755.44   684.7  735.81   701.8  734.52
   735.5  735.72     748  741.83   802.8  740.96   840.7  737.34   962.8  740.95
  1004.9   751.2  1055.5  752.03  1063.9  756.65  1072.3  773.38  1076.5   777.2
  1101.8  793.36  1264.3   881.1  1327.5  908.96  1368.5  919.22  1405.6  925.04
#Mann= 5 ,-1,0
       0      .1       0   684.7    .045       0   735.5      .1       0
  942.89     .06       0 1143.52      .1       0
Bank Sta=684.7,735.5
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,57989   ,460.3,483.1,504.4
XS GIS Cut Line= 6
1622695.87013987408907.334967388 1622677.4049537409007.749792812
 1622679.6214847409107.0714445541622721.47277894409732.246703384
1622720.14010444409914.0790168921622699.97643086410311.465689315
#Sta/Elev= 30
       0  853.55    58.2  852.66   162.9  843.44   219.8  841.66   491.7  802.19
   523.8  796.28   559.9  784.67     616  757.41     628  745.95   636.1  741.64
   672.2   739.5   684.2  734.09   736.3  733.52  750.44734.0854   772.4  739.97
   960.4  741.12   988.7  752.09  1044.4  753.85  1052.4  760.17  1064.5  781.83
  1072.5  788.29  1116.5  808.28  1160.6  834.76  1200.6  853.11  1232.7  876.03
  1300.8  915.72  1332.8  926.14  1376.9  932.58  1392.9  938.87  1407.9  949.43
#Mann= 5 ,-1,0
       0      .1       0   684.2    .045       0  750.44      .1       0
  955.84     .06       0 1049.95      .1       0
Bank Sta=684.2,750.44
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,57506   ,487.6,500,514.8
XS GIS Cut Line= 6
1622685.01565284 408910.48792325  1622638.142387409005.278744176
 1622524.2390715409176.3948717561622463.55152884409255.508886755
1622295.21197051409450.309022084 1621826.4451915410036.264543086
#Sta/Elev= 30
       0  851.63      96  843.94   194.3  821.61   263.5     810   365.8  795.24
   407.4  793.76   479.6  775.98   533.4  757.36     576  749.55   601.5  741.23
   645.1  739.56   688.6  733.24   707.3  732.55   739.9  733.24     779  738.67
   801.6  748.98   860.2  750.35   878.5  755.91   927.6  781.24   959.8  803.81
  1000.1  818.93  1025.7  839.79  1053.7  850.34  1082.2  878.41  1113.5  901.75
  1153.8  916.61  1247.2  940.32  1270.8  949.31  1332.6  981.19    1419 1011.66
#Mann= 4 ,-1,0
       0      .1       0   688.6    .045       0   739.9     .06       0
  941.09      .1       0
Bank Sta=688.6,739.9
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,57006   ,491.4,500,509.7
XS GIS Cut Line= 6
 1622540.9283426408790.8424932511622447.77137667 408849.15536876
1622358.58421908408911.972828418 1622196.1255545409042.311806589
1622115.31370826409094.0571099221621265.95287417409428.654209763
#Sta/Elev= 30
       0  812.31    59.9  810.54   164.4  797.04   370.9  755.71   552.3  740.57
   702.9  737.52  715.43731.3958   759.2  730.15   768.2   731.5   793.2     750
   823.7   754.2   842.2  753.65     862  763.71     905  797.18   917.9  813.89
   930.8   821.1   956.3  841.32   978.1  852.73  1021.1  882.35  1039.6  891.34
  1056.5  906.46  1081.3   923.9  1145.8   942.6  1158.7  949.99  1171.5  963.58
  1180.1  968.51  1210.2  978.68  1330.6  997.78  1388.1  1000.3  1436.1  996.72
#Mann= 7 ,-1,0
       0      .1       0  457.27     .05       0  670.73      .1       0
  715.43    .045       0   768.2      .1       0  775.73     .06       0
  880.73      .1       0
Bank Sta=715.43,768.2
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,56506   ,514,500,486.7
XS GIS Cut Line= 6
1622529.50776176408668.8132097571622429.59391959408669.524494424
1622330.17548326408671.3899762631622134.86288175408679.282348916
1621953.61291617 408685.03725867 1621128.2221785408685.539226174
#Sta/Elev= 30
       0   804.2    53.4   789.6    73.4  787.77    97.4  782.06   157.4  778.07
   321.5  756.13   417.6  746.03   513.6  739.16   661.7  736.09   676.7  730.29
   704.7  729.63  719.16730.3299   741.7  734.73   769.7  753.98   777.7  757.68
   809.7  758.23   813.7  761.73   821.7  777.63   829.7   786.8   869.7  813.52
   897.7  825.22   925.7   845.4   973.7   861.7  1005.7  865.42  1177.7   852.7
  1197.7  840.62  1205.7  838.17  1233.7  847.51  1329.7  854.34  1401.6  869.48
#Mann= 9 ,-1,0
       0      .1       0  558.63     .05       0  651.17      .1       0
   676.7    .045       0  719.16      .1       0  751.17     .06       0
  846.17      .1       0 1047.42     .05       0 1144.29      .1       0
Bank Sta=676.7,719.16
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,56006   ,134.6,141,145.7
XS GIS Cut Line= 6
1622308.07775842 407820.102308751621545.43263017408321.840806589
1621464.39079751 408369.230475591621378.41820042 408414.81174925
1621289.57520226408458.6098899991621107.55227233408542.415824756
#Sta/Elev= 30
       0  829.46    57.4  817.19   101.4  814.83   129.2  809.75   205.3   773.2
   303.5  747.68   349.5  743.63   641.2  736.22   675.1  729.51   684.7  728.94
   725.2  729.55   756.5  737.08   780.4  754.76   811.8  753.37   814.7  755.73
   823.5  770.62   837.7  779.24   904.2  807.96   923.7  813.24   988.6  819.35
  1133.4  811.97  1146.8  808.85  1169.1  810.07  1191.4  804.89    1218  795.42
  1248.9  808.96  1266.5  818.93  1345.8  842.36  1376.5  849.55  1403.5  852.08
#Mann= 8 ,-1,0
       0      .1       0  394.14     .05       0  484.14     .06       0
  635.39      .1       0   675.1    .045       0   725.2      .1       0
  750.39     .06       0  982.89      .1       0
Bank Sta=675.1,725.2
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55865   ,58.2,59.6,60.8
BEGIN DESCRIPTION:
Structure 14 XS 4
END DESCRIPTION:
XS GIS Cut Line= 6
1622140.60236891407798.5582331681621774.61680278408080.288129403
1621739.07144204408065.8066861381621692.99412256408068.439675823
1621537.64773118 408126.365448881621216.42298967 408221.15307752
#Sta/Elev= 30
       0  856.69      36  840.46    53.1  824.51    73.1  810.85    86.4  797.08
   106.6  786.67   121.8  782.36   160.6  779.16   218.5  756.59   258.5  744.35
   291.8  741.45   444.8  738.82   473.2  735.63   531.5  735.96   552.3  733.93
   563.4  728.99   575.7  727.94  612.78729.0833   622.5  735.07   650.4  738.73
   672.3  751.41   701.7  749.17   714.5  756.94   722.8  758.98   772.9  758.78
   793.7  757.19   810.4  766.17   831.3   770.8   877.6   792.7  1047.8  837.12
#Mann= 8 ,-1,0
       0      .1       0     310     .05       0     330     .06       0
   563.4    .045       0  612.78      .1       0  667.11     .07       0
   772.9     .06       0   872.9      .1       0
Bank Sta=563.4,612.78
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55806   ,300.5,299.4,299
BEGIN DESCRIPTION:
Structure 14 XS 3
END DESCRIPTION:
XS GIS Cut Line= 6
1622122.17144112407769.5953466391621779.88278214408018.412871818
1621729.85597814408006.5644182381621691.67762772408009.197407923
1621577.14257644408046.0592635051621221.68896904408156.644830251
#Sta/Elev= 30
       0  866.51      15  853.58    32.2  843.22    52.6  821.49    81.7  800.23
    98.1  791.16   112.4  786.92   170.7  783.42   212.6  760.15   221.2     757
   292.8  741.56   403.1  739.86   492.4  734.95   533.4  737.91     546  734.95
   554.4  729.43   562.8  727.94  606.48729.4793   621.7  738.31   664.7  743.34
   681.9  751.51   712.7  749.45   726.4  750.48     739  753.07   764.1  766.23
     806   766.7     827  780.86   835.3  781.98   864.7  794.64  1005.4  828.53
#Mann= 7 ,-1,0
       0      .1       0     300     .06       0   554.4    .045       0
  606.48     .06       0  632.86     .07       0  763.19     .06       0
  833.19      .1       0
Bank Sta=554.4,606.48
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55506   ,512.5,500,481.9
BEGIN DESCRIPTION:
Structure 14 XS 2
END DESCRIPTION:
XS GIS Cut Line= 6
1622175.00518993 407517.961508841621715.20295992407681.115382001
1621135.02072135407886.9857051671621042.25384651 407919.91378893
1620949.24451809407954.4950845841620862.21713309 408007.10226284
#Sta/Elev= 30
       0  915.99    92.2   889.6   145.2  856.64   175.2  844.46   207.9  821.47
     245  804.02   283.2  774.41   334.1  753.97   390.5  745.12   458.5  742.36
   503.9  735.94   660.9  735.98   675.9728.8525   690.7   727.5   727.9  729.03
   737.3  734.03   758.6  736.76     784  745.85   978.6  754.31  1000.5  759.06
  1044.4  758.46  1056.9  762.71  1097.6   766.9  1127.8  773.49  1213.4  802.49
  1272.6  811.25  1311.9  810.55  1345.8  805.62  1370.5  798.89  1402.9  781.46
#Mann= 9 ,-1,0
       0      .1       0  424.14     .05       0  625.39      .1       0
   675.9    .045       0   727.9      .1       0  810.39     .05       0
  835.39     .06       0 1103.52     .05       0 1251.95      .1       0
Bank Sta=675.9,727.9
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55006   ,518.3,503.7,490.8
BEGIN DESCRIPTION:
Structure 14 XS 1
END DESCRIPTION:
XS GIS Cut Line= 6
1621654.09350209406762.1401858331621188.00946051407443.341579333
1621030.95793734407672.8811465051620963.99153584407747.072927251
1620896.32926959407834.7804290061620835.75950883407947.245099083
#Sta/Elev= 30
       0   792.3    23.3  789.86    54.9  777.97    85.3  790.84   109.5  794.88
   193.1  786.89     242  787.18     347  766.57   419.7  741.09   477.9   740.5
   511.8  735.78   548.9  743.79   598.5  746.57   619.8  744.23   644.9  735.43
  681.48727.8368   720.2  727.02   728.3  727.85   748.5   733.9   898.1  735.91
   972.9  747.23  1067.9  746.45  1149.5  753.32  1167.6  757.81  1195.9  755.95
  1242.6  767.74  1311.4  796.57  1339.3  803.87  1384.4  807.97    1442  803.44
#Mann= 9 ,-1,0
       0      .1       0  681.48    .045       0   728.3      .1       0
  770.39     .05       0  992.89     .06       0 1006.64     .05       0
 1133.52     .06       0 1313.46     .05       0 1374.23      .1       0
Bank Sta=681.48,728.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54502   ,503.6,502.5,502.4
XS GIS Cut Line= 6
1620616.99518259406484.164363846 1620837.3431671407279.608639091
1620856.90119883407467.9432361721620859.14758542407686.193783924
1620843.90745842407804.3408573421620809.54860325407932.025313258
#Sta/Elev= 30
       0  796.27    33.6  782.82      96  774.28   158.8  761.72   220.7  764.24
   262.2  762.83   424.3  814.07   478.3  824.63   503.3  832.41   532.4  833.38
   561.5  826.68     603  801.48     628  781.19   651.2  758.24   674.6  726.51
   686.1  725.11   702.8  726.54   731.9  726.53   760.8  733.16  1011.5  733.19
    1070  745.43  1171.9   749.7  1207.5  755.63    1238  752.64  1247.7  756.74
    1284  763.02  1364.9  797.69  1384.9  803.68  1443.7  806.63  1484.5  802.47
#Mann= 8 ,-1,0
       0      .1       0   674.6    .045       0   702.8      .1       0
  845.49     .05       0 1141.96     .08       0 1243.19     .06       0
 1343.19     .05       0 1442.32      .1       0
Bank Sta=674.6,702.8
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54000   ,520,500,487
XS GIS Cut Line= 6
1620085.97754385406723.5949873331620374.58949943407416.262893334
1620405.90013234407484.4668251721620444.01291701407563.378084674
1620617.29701926 407911.81472376   1620667.19751 407998.93265976
#Sta/Elev= 30
       0 1017.84      40 1020.87     105 1013.49   148.4  996.71   226.4  954.63
   243.7  952.94   308.7  936.17     352  910.87   395.4  897.85     430   875.1
     469  857.95     495  840.49   516.7  830.88   537.6  815.89   555.7  808.61
   568.7     800   601.9  770.29   633.7  753.97     664  731.07     677   724.5
   685.7  723.57   725.8  724.65   746.4  730.69  1070.5  736.62  1131.9  741.86
  1155.8  747.89  1218.1  746.55  1339.9  755.64    1363  754.56  1402.6  765.26
#Mann= 6 ,-1,0
       0      .1       0     677    .045       0   725.8      .1       0
  825.44     .05       0 1057.01     .07       0  1164.1      .1       0
Bank Sta=677,725.8
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,53500   ,491.2,500,504.9
XS GIS Cut Line= 6
1619384.74731901407395.7780261781619562.58456175407484.696483508
1619966.47384584 407686.641945751620459.80586442407933.309759513
1620548.54978143407977.6813899281620632.82421917408031.865992844
#Sta/Elev= 30
       0  944.62    66.4  945.26   124.5  937.39   171.6  908.88   202.8  896.31
   249.7  853.43   298.9  888.58   348.9  899.56   383.9  897.59   462.2  853.47
   513.6  818.88   535.9   808.7   580.7   776.7   614.3  761.56   647.1   740.9
   656.7  729.01   665.6  723.66   670.1  722.97   710.4  723.66   730.3  728.22
   884.8  729.12  1130.7  740.98  1153.9  746.58  1183.7  746.79  1200.2  765.83
  1228.4  775.52  1252.3  769.65  1305.4  746.42  1367.2  752.12  1401.4  761.51
#Mann= 5 ,-1,0
       0      .1       0   665.6    .045       0   710.4     .05       0
 1103.52     .06       0 1143.52      .1       0
Bank Sta=665.6,710.4
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,53000   ,498,500,504.1
XS GIS Cut Line= 6
1619206.70436801407622.7086746691619275.37385009407695.120603338
1619345.44851309407765.464294672  1619417.522844407832.510420427
1619488.45413259407898.4919157621620225.50482383408584.116856843
#Sta/Elev= 30
       0  832.68    42.7   828.2    74.2  821.37   146.2  801.56   180.2  786.06
   186.5  787.99   208.2  786.31   250.6  778.93   262.6  773.65   279.6  761.57
   333.8  772.39   353.2  773.67   486.8  765.02   503.2   761.1   573.9  753.91
   624.9  736.89   641.8  726.97   653.2  723.96     678  723.62   696.9  722.44
   729.6  723.77   738.1     728  1072.8  729.44    1089  735.81  1120.2  735.07
  1166.7  763.04  1213.6  775.14  1284.4  805.98    1372  832.86    1401  837.42
#Mann= 8 ,-1,0
       0      .1       0     678    .045       0   729.6      .1       0
  810.65     .05       0  983.15     .06       0 1113.77      .1       0
 1381.43     .05       0 1391.43      .1       0
Bank Sta=678,729.6
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52500   ,498.7,500,502.1
XS GIS Cut Line= 6
1618941.51067267407879.4781742541619051.67383817408045.370559007
1619108.28264885408125.9806340041619536.64465301408691.417495251
1619653.03582442408848.2738088371619770.00048551409009.105836257
#Sta/Elev= 30
       0  901.11      12  900.45    58.8   906.3   121.1  923.41   149.6  924.34
   216.1  895.19   269.5  864.22     291  855.77   325.9  836.91   416.4  794.63
   546.7  765.53     627  729.46   659.1  723.68   681.6  723.45   693.4  720.88
   719.1  720.59  728.45720.9791   742.5  726.89  1088.4  725.78  1108.3  730.85
  1141.8   732.1  1181.8  755.92  1217.5   772.8  1227.6  781.41  1247.2  788.67
  1276.9  813.44  1296.3  823.82  1326.4  835.47    1356  854.94  1401.2  868.72
#Mann= 6 ,-1,0
       0      .1       0  660.77     .05       0   693.4    .045       0
  728.45     .05       0 1113.89     .06       0 1232.34      .1       0
Bank Sta=693.4,728.45
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1
